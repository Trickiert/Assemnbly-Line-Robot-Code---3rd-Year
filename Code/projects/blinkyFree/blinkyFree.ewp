# IAR project blinkyFree.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_2378_SK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\NXP; include; ..\..\bsp\include; ..\..\FreeRTOSV7.1.0\Source\include; ..\..\FreeRTOSV7.1.0\Source\portable\IAR\LPC2378
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\INC\NXP; include; ..\..\bsp\include; ..\..\FreeRTOS\Source\include; ..\..\FreeRTOS\Source\portable\IAR\LPC2000
  OBJCOPY.OOCOutputFile: a.srec
  ILINK.IlinkOutputFile: a.out
  ILINK.IlinkIcfFile: config\LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../bsp/src/: accelerometer.c adc.c bsp.c buttons.c can.c delay.c lcd.c leds.c potentiometer.c pwm.c
  group bsp/lcd
    ../../bsp/src/lcd/: drv_glcd.c glcd_ll.c
  group bsp/lcd/fonts
    ../../bsp/src/lcd/fonts/: Terminal_9_12x6.c
  group FreeRTOS/include
    ../../FreeRTOSV7.1.0/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable
    ../../FreeRTOSV7.1.0/Source/portable/MemMang/: heap_1.c
    ../../FreeRTOSV7.1.0/Source/portable/IAR/LPC2378/: ISR_Support.h lpc2378_cstartup.s lpc2378_timers.c port.c portasm.s79 portmacro.h
  group FreeRTOS/src
    ../../FreeRTOSV7.1.0/Source/: croutine.c list.c queue.c tasks.c timers.c
  group project/include
    include/: FreeRTOSConfig.h
  group project/src
    src/: main.c
